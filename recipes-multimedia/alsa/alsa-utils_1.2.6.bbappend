FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-first-time.patch \
            file://0001-second-time-change.patch \
            "

