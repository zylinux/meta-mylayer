inherit externalsrc
EXTERNALSRC = "/home/mjj/projects/yocto/hellopoky"
